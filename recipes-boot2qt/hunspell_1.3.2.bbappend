RDEPENDS_hunspell_append = "perl"
